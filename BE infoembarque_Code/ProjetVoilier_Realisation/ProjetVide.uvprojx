# Keil uVision project ProjetVide.uvprojx, settings and files
target Reel (6190000::V6.19::ARMCLANG)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Projet3FISA
  c flags: Optim=1 OneElfS=1 v6LangP=3 wLevel=2
  c include: ..\Driver
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application
    ./Application/: principal.c
  group TPGPIO
    ./: GPIO.c
  group TPTIMER
    ./: TIMER.c
  group TPADC
    ./: ADC.c
  group Driver
    ../Driver/: MyGPIO.c MyTimer.c MyADC.c MySPI.h Lib_Com_Periph_2022.lib MyEncoder.c
target Simulation (6190000::V6.19::ARMCLANG)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: as above
  output: ProjetVide
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: ..\Driver
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
software components: CMSIS:CORE 6.1.0, Device:Startup 1.0.0
