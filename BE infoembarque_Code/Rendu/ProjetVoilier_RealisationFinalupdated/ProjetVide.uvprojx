# Keil uVision project ProjetVide.uvprojx, settings and files
target Reel (6190000::V6.19::ARMCLANG)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Projet3FISA
  c flags: Optim=1 OneElfS=1 v6LangP=3 wLevel=2
  c include: ..\Driver
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application
    ./Application/: principal.c
  group TPGPIO
    ./: GPIO.c
  group TPTIMER
    ./: TIMER.c
  group TPADC
    ./: ADC.c
  group Driver
    ../Driver/: DS1307.h Lib_Com_Periph_2022.lib MyADC.c MyADC.h MyDS1307.c MyEncoder.c MyEncoder.h MyGPIO.c MyGPIO.h MyI2C.h MyPLATEAU.c MyPLATEAU.h MySPI.h MyTimer.c MyTimer.h MyUSART.c MyUSART.h myApplication.c myApplication.h
target Simulation (6220000::V6.22::ARMCLANG)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: as above
  output: ProjetVide
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: ..\Driver
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
software components: CMSIS:CORE 6.1.0, Device:Startup 1.0.0
